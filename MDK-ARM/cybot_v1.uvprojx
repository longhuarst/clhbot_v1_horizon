# Keil uVision project cybot_v1.uvprojx, settings and files
target cybot_v1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cybot_v1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;   ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cylib/bsp
    ../code/cylib/bsp/: cy_bsp.c cy_bsp.h cy_can.c cy_can.h cy_gpio.c cy_gpio.h cy_timer.c cy_timer.h cy_uart.c cy_uart.h
  group cylib/middle
    ../code/cylib/middle/: cy_input.c cy_input.h cy_io.c cy_io.h cy_led.c cy_led.h cy_output.c cy_output.h cy_pwm.c cy_pwm.h cy_servo.c cy_servo.h cy_stepper.c cy_stepper.h cy_gcoder.c cy_gcoder.h cy_string.c cy_string.h cy_controller.c cy_controller.h
  group cylib/buffer
    ../code/cylib/buffer/: cy_circular_buffer_u8.c cy_circular_buffer_u8.h
  group cylib/controller
    ../code/cylib/controller/: cy_abb.c cy_abb.h cy_b.c cy_b.h
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
software components: CMSIS:CORE 4.3.0
